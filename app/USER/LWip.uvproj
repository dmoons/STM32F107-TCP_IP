# Keil uVision project LWip.uvproj, settings and files
target LWip (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LWip +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin --output ./bin/stm32_app.bin ../OBJ/LWip.axf
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\STM32F107_ETH\inc;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\include\netif;..\lwip-1.4.1;..\TCP_CLIENT;..\Driver\uart;..\Driver\system;..\Driver;..\Driver\SPI_Flash
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../Driver/uart/: usart.c data_transfer.c
    ../Driver/system/: ke_timer.c usr_task.c
    ../Driver/: stmflash.c common.c commucation.c iap_code.c usr_lwip.c usr_design.c crc.c wdg.c relay.c led.c products_test.c
    ../Driver/SPI_Flash/: flash.c spi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group STM32F107_ETH
    ../STM32F107_ETH/src/: stm32_eth.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LWip-NETIF
    ../lwip-1.4.1/src/netif/: ethernetif.c etharp.c
  group LWip-API
    ../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWip-CORE
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWip-ARCH
    ../lwip-1.4.1/arch/: sys_arch.c
  group TCP_CLIENT
    ../TCP_CLIENT/: tcp_client_demo.c
