# Keil uVision project 串口通信.uvproj, settings and files
target 串口通信 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: 串口通信 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\CORE;..\HARDWARE\inc;..\STLIB\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/scr/: iap.c stmflash.c flash.c spi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c
  group HARDWARE
    ../HARDWARE/scr/: delay.c usart.c
